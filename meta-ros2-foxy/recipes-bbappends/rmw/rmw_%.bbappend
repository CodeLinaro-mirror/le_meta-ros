FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Resolve-attribute-issue-on-rmw-native.patch"
