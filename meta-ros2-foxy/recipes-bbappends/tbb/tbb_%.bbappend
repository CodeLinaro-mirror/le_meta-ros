CXXFLAGS += "-fPIC"
