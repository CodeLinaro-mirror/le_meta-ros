FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-modify-realsense2-camera-CMakeLists.txt.patch"
