SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=7db0397b3bef91c94678b9b54b033505"

DEPENDS += "ament-cmake-ros"

require ecl-tools.inc

