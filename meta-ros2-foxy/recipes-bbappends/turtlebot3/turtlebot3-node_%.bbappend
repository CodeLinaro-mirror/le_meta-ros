FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-remove-add-device-in-turtlebot3-node-application.patch"
