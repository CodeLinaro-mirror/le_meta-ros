SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=6cef6a2a0fb4ff3277953f336436118f"

DEPENDS += "ament-cmake console-bridge ros2-geometry-msgs"

require geometry2.inc
