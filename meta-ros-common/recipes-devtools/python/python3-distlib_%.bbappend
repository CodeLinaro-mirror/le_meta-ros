FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-setup.py-fix-invalid-command-bdist_wheel.patch "
