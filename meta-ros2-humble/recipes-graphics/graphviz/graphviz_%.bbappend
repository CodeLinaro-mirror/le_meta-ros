EXTRA_OECONF:append:class-target = " --with-tclsh=${STAGING_LIBDIR} "
EXTRA_OECONF:append:class-nativesdk = " --with-tclsh=${STAGING_LIBDIR} "
